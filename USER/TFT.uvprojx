# Keil uVision project TFT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 跑马灯 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SAVE;..\SAVE\MPU6050;..\SAVE\MPU6050\eMPL;..\SAVE\24CXX;..\SAVE\Algorithm\Algorithm_filter;..\SAVE\Algorithm\Algorithm_math;..\SAVE\TIM;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SAVE
    ../SAVE/: led.c IIC.c MS5611.c HMC5883L.c IMU.c control.c motor.c sand_data.c hight.c
    ../SAVE/MPU6050/: mpu6050.c
    ../SAVE/24CXX/: 24cxx.c
    ../SAVE/TIM/: timer3.c
    ../SAVE/Algorithm/Algorithm_math/: Algorithm_math.c
    ../SAVE/Algorithm/Algorithm_filter/: Algorithm_filter.c
    ./: RC.c
  group Readme
    ../: Readme.txt
